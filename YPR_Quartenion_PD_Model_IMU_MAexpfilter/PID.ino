
//////////////////////////////PD CONTROL///////////////////////////

float pwm_awal =0;
double tau_x,tau_y,tau_z;
double k = 0.0263218;
double bp = 0.0411844;
float d = 8.85;        //cog to motor
double T_vec = 11.5;  // Total Thrust (4motor) 

/* dc = 1100 (12 g) --- N = 0.1178798 X 4 = 0.47
 dc = 1200   (58 g) --- N = 0.5687857     = 2.27
 dc = 1300 (147 g)  --- N = 1.4415775     = 5.76
 dc = 1400 (206 g)  --- N = 2.0201699     = 8.00
 dc = 1500 (293 g)  --- N = 2.8733484     = 11.50 twr 1.3
 dc = 1600 (394 g)  --- N = 3.8638201     = 15.45
 dc = 1700 (508 g)  --- N = 4.9817782     = 20.00
 dc = 1800 (599 g)  --- N = 5.8741833     = 23.50
 dc = 1900 (686 g)  --- N = 6.7273619     = 27.00
 dc = 2000 (719 g)  --- N = 7.0509813     = 29.20*/


double T1_N,T2_N,T3_N,T4_N;
double T1_g,T2_g,T3_g,T4_g;
double a = 0.0004;
double b = 0.4019;
double c = -6.9971;
float x1_1,x2_1,x1_2,x2_2,x1_3,x2_3,x1_4,x2_4;
float c_y1,c_y2,c_y3,c_y4;
double ampYaw = 0.1;
float k1=1;
float k2=1;
float dta = 0.2;
float Ka = 0.1;
int gy1;

float RunningAverageDerivative_roll = 0;
float RunningAverageDerivative_pitch = 0;
float RunningAverageDerivative_yaw = 0;
  
void compensation(){
  gy1 = abs(gy);

if((roll1 < 5) && (gy1 < 10))
{
 u= -(dta*((k1*roll)+(k2*gy))/(abs((k1*roll)+(k2*gy)))+ Ka);    
}
}

void moving_avg_filter(){
  
Derivative_roll = (kd_roll*gy);
Derivative_pitch = (kd_pitch*gx);
Derivative_yaw = (kd_yaw*gz);
RunningAverageDerivative_roll = average1.update(Derivative_roll);
RunningAverageDerivative_pitch = average2.update(Derivative_pitch);
RunningAverageDerivative_yaw = average3.update (Derivative_yaw);
}

void PD_control() {
//kp roll 2.9, kd roll 1.6
//kp pitch 2.5 , kd pitch 0.4
//kp yaw 0.5    , kd yaw 0.39
  //menggunakan RC
  sp_roll = roll - roll_rc;
  sp_pitch = -pitch -pitch_rc;
  sp_yaw = yaw_val -yaw_rc;
  
    tau_x = (-kp_roll*0.01)-(RunningAverageDerivative_roll)+u;     //gy = kecepatan sudut sumbu x (p)
    tau_y = (-kp_pitch*0.01)-(RunningAverageDerivative_pitch);       //gx = kecepatan sudut sumbu y (q)
    tau_z = (-kp_yaw*sp_yaw)-(RunningAverageDerivative_yaw);   //gz = kecepatan sudut sumbu z (r)

   T1_N = (-bp/(4*k))*tau_z + (-sqrt(2)/(4*d))*tau_y + (-sqrt(2)/(4*d))*tau_x + (1/4)*T_vec;
   T2_N = (bp/(4*k))*tau_z + (-sqrt(2)/(4*d))*tau_y + (sqrt(2)/(4*d))*tau_x + (1/4)*T_vec;
   T3_N = (-bp/(4*k))*tau_z + (sqrt(2)/(4*d))*tau_y + (sqrt(2)/(4*d))*tau_x + (1/4)*T_vec;
   T4_N = (bp/(4*k))*tau_z + (sqrt(2)/(4*d))*tau_y + (-sqrt(2)/(4*d))*tau_x + (1/4)*T_vec;

//thrust 1400 to 1800
if(T1_N < pwm_awal)
{
  T1_N = pwm_awal;
}
if(T1_N  > 2.020169)
{
  T1_N =2.020169;
}

//Left front
if(T2_N  < pwm_awal)
{
 T2_N = pwm_awal;
}
if(T2_N  >2.020169)
{
  T2_N =2.020169;
}

//Right back
if(T3_N  < pwm_awal)
{
  T3_N = pwm_awal;
}
if(T3_N  > 2.020169)
{
  T3_N =2.020169;
}

//Left back
if(T4_N  < pwm_awal)
{
  T4_N = pwm_awal;
}
if(T4_N  >2.020169)
{
  T4_N =2.020169;
}
   //Newton to gram
   T1_g = T1_N * 101.9716; //1Newtons = 101.9716 grams
   T2_g = (T2_N * 101.9716);
   T3_g = T3_N * 101.9716;
   T4_g = (T4_N * 101.9716);

  //Thrust in gram equal to y
  c_y1 = c - T1_g;
  c_y2 = c - T2_g;
  c_y3 = c - T3_g;
  c_y4 = c - T4_g;
  
  //x1_1 = (-b + sqrt((b*b)-(4*a*c_y1)))/(2*a); 
  x2_1 = (-b - sqrt((b*b)-(4*a*c_y1)))/(2*a); //benar

  //x1_2 = (-b + sqrt((b*b)-(4*a*c_y2)))/(2*a);
  x2_2 = (-b - sqrt((b*b)-(4*a*c_y2)))/(2*a);
  
  //x1_3 = (-b + sqrt((b*b)-(4*a*c_y3)))/(2*a);
  x2_3 = (-b - sqrt((b*b)-(4*a*c_y3)))/(2*a);
  
  //x1_4 = (-b + sqrt((b*b)-(4*a*c_y4)))/(2*a);
  x2_4 = (-b - sqrt((b*b)-(4*a*c_y4)))/(2*a);

pwm_R_F = abs(x2_1)+INPUT_THROTTLE;
pwm_L_F = abs(x2_2)+INPUT_THROTTLE;
pwm_L_B = abs(x2_3)+INPUT_THROTTLE;
pwm_R_B = abs(x2_4)+INPUT_THROTTLE;



}
