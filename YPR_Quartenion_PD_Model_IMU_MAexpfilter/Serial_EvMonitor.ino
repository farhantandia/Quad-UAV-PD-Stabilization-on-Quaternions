void Serial_EventArd(){

  if (Serial.available() > 0)
  {
    char e = (char)Serial.read();
    if(e =='1'){
     pwm_L_F = 1070;
     pwm_L_B = 1070;
     pwm_R_B = 1070;
     pwm_R_F = 1070;
      Serial.println("Motor ON");
    }
    if(e =='d'){
      flag_compensation = 1;
      Serial.println("Compensation ON");
    }
    if(e =='a'){
      flag_compensation = 0;
      Serial.println("Compensation OFF");
     }
    if(e =='x'){
      flag_pid = 1;
      Serial.println("PD Control ON");
      pwm_awal = 0.5687857;
      kp_roll = 2.9;
      kd_roll = 1.6;
      Serial.println("PD MOTOR ON");
    }
    if(e =='z'){
       flag_pid = 0;
       pwm_L_F = 1000;
       pwm_L_B = 1000;
       pwm_R_B = 1000;
       pwm_R_F = 1000;
      Serial.println("Motor OFF");
      Serial.println("PD Control OFF");
     }
     
    if(e =='v'){
      flag_RC = 1;
      Serial.println("RC ON");
    }
    if(e =='c'){
      flag_RC = 0;
      Serial.println("RC OFF");
     }
     
      if(e =='p'){
      Serial.println(" ");
      Serial.print("Proportional Constant+ ");
      kp_roll += 0.1; //didapat untuk yaw kp 0.088 dan kd 0.044 dan tidak berlaku pada pitch dan roll
      Serial.print(kp_roll);
      Serial.println(" ");
    }
    if(e =='o'){
      Serial.println(" ");
      Serial.print("Proportional Constant- ");
      kp_roll -= 0.1;
      Serial.print(kp_roll);
      Serial.println(" ");
    }
     if(e =='l'){
      Serial.println(" ");
      Serial.print("Derivative Constant+ ");
      kd_roll += 0.1;
      Serial.print(kd_roll);
      Serial.println(" ");
    }
    if(e =='k'){
      Serial.println(" ");
      Serial.print("Derivative Constant- ");
      kd_roll -= 0.1;
      Serial.print(kd_roll);
      Serial.println(" ");
      
    }
     if(e =='j'){
      Serial.print("dta+ ");
      dta += 0.05;
      Serial.println(dta);
    }
    if(e =='h'){
      Serial.print("dta- ");
      dta -= 0.05;
      Serial.println(dta);
    }
    if(e =='m'){
      Serial.print("Ka+ ");
      Ka += 0.05;
      Serial.println(Ka);
    }
    if(e =='n'){
      Serial.print("Ka- ");
      Ka -= 0.05;
      Serial.println(Ka);
    }
    if(e =='r'){
      kp_roll = 0;
      kd_roll = 0;
      kp_pitch = 0;
      kd_pitch = 0;
      kp_yaw = 0;
      kd_yaw = 0;
      Serial.println("KP & KD = 0");
     }
    if(e == 'j'){
      ampYaw += 0.01;
      Serial.print("Amplifikasi yaw ");
      Serial.println(ampYaw);
    }
     if(e == 'h'){
      ampYaw -= 0.01;
      Serial.print("Amplifikasi yaw ");
      Serial.println(ampYaw);
    }
  }
}

